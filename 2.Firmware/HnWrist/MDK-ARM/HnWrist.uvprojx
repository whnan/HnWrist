# Keil uVision project HnWrist.uvprojx, settings and files
target HnWrist (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HnWrist +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,STM32F411xE
  c misc: --gnu
  c include: ..\ArduinoAPI;..\Core;..\Libraries;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Core\CMSIS\Device\ST\STM32F4xx\Include;..\HnWrist
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Basic
    ../HnWrist/Basic/: main.cpp SysConfig.h
  group BSP
    ../HnWrist/BSP/: BSP.h BSP_Backlight.cpp BSP_BMP.cpp BSP_Button.cpp BSP_IMU.cpp BSP_LED.cpp BSP_Power.cpp
  group GUI
    ../HnWrist/GUI/: DisplayAppWin.cpp DisplayBasic.cpp DisplayError.cpp DisplayPrivate.h lv_ext_func.cpp lv_port_disp.cpp
  group GUI/Page
    ../HnWrist/GUI/Page/: Page_About.cpp Page_Altitude.cpp Page_BacklightCfg.cpp Page_DialPlate.cpp Page_EXAMPLE.cpp Page_MainMenu.cpp Page_StopWatch.cpp Page_TimeCfg.cpp
  group GUI/IMG
    ../HnWrist/GUI/IMG/: ImgBg.c ImgButterfly.c ImgInfo.c ImgLight.c ImgMountain.c ImgPage1.c ImgPressure.c ImgRun.c ImgSettings.c ImgShadowDown.c ImgShadowUp.c ImgStopWatch.c ImgTemperature.c ImgTimeCfg.c ImgTrigger.c ImgVIFEXTech.c ImgWatchX.c
  group GUI/Font
    ../HnWrist/GUI/Font/: EuroStar_26.c EuroStar_60.c EUROSTARBLACKEXTENDED.TTF HANDGOTN.TTF HandGotn_14.c HandGotn_20.c HandGotn_26.c Morganite_36.c Morganite_100.c Morganite-Bold.ttf
  group Game
    ../HnWrist/Game/: GameDisp.cpp GameDisp.h GameManager.cpp GamePrivate.h Page_Game.cpp Page_GameSelect.cpp
  group Game/Arduboy
    ../HnWrist/Game/Arduboy/: ab_logo.c Arduboy.cpp Arduboy.h glcdfont.c
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libraries/Adafruit_BMP180/: Adafruit_BMP085.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EEPROM_File/: EEPROM_File.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/PageManager/: PageManager.cpp
    ../Libraries/SoftSerial/: SoftSerial.cpp
    ../Libraries/Time/: DateStrings.cpp Time.cpp
  group LittlevGL
    ../Libraries/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libraries/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../Libraries/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
    ../Libraries/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libraries/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../Libraries/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../Libraries/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp WString.cpp Stream.cpp WMath.cpp HardwareSerial.cpp WireBase.cpp Wire.cpp SPI.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c rtc.c
    ../CORE/: delay.c
  group cm_backtrace
    ../Libraries/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group STM32F4xx_StdPeriph_Driver
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Core/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f401xx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f413_423xx.s startup_stm32f427_437xx.s startup_stm32f427x.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group CMSIS
    ../Core/: system_stm32f4xx.c
software components: CMSIS:CORE 5.2.0
